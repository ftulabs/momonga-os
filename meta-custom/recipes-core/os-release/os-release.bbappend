# Momonga operating-system branding.
ID = "momonga"
NAME = "MomongaOS"
VERSION = "1.0"
VERSION_ID = "1.0"
PRETTY_NAME = "MomongaOS 1.0"
CPE_DISTRO = "momonga"
