# Publish the TensorRT Python bindings in the same architecture directory as
# the other Xavier ARM64 RPMs in the public feed.
PACKAGE_ARCH = "armv8a_tegra"
